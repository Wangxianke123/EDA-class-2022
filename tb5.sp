Source test

Vin 3 0 DC 5
V1 4 0 AC 1 90
V2 1 0 TRAN sin (0 1 1 0 0)
Is1 0 1 1 0 tran const(1)
Is2 0 1 1 const(1)
V3 2 0 PULSE (0 1 1 1 1 1 10)
